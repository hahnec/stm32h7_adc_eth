<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\H743ZI_LwIP_ADC+ETH.ewp</path>
  </project>
  <batchBuild />
</workspace>
